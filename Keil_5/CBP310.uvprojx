# Keil uVision project CBP310.uvprojx, settings and files
target sps_device_580 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: sps_device_580 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\;.\..\..\..\..\..\sdk_580\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\..\sdk_580\sdk\app_modules\api;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk_580\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\sdk_580\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk_580\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk_580\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk_580\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\accel;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\ieu;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\mpu;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\sample128;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wpt;.\..\..\..\..\..\sdk_580\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\sdk_580\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk_580\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk_580\sdk\common_project_files;.\..\..\..\..\..\sdk_580\sdk\platform\arch;.\..\..\..\..\..\sdk_580\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk_580\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk_580\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk_580\sdk\platform\arch\main;.\..\..\..\..\..\sdk_580\sdk\platform\arch;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk_580\sdk\platform\driver\accel;.\..\..\..\..\..\sdk_580\sdk\platform\driver\adc;.\..\..\..\..\..\sdk_580\sdk\platform\driver\battery;.\..\..\..\..\..\sdk_580\sdk\platform\driver\bme280;.\..\..\..\..\..\sdk_580\sdk\platform\driver\coex;.\..\..\..\..\..\sdk_580\sdk\platform\driver\coex;.\..\..\..\..\..\sdk_580\sdk\platform\driver\emi;.\..\..\..\..\..\sdk_580\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk_580\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\..\sdk_580\sdk\platform\driver\i2c_core;.\..\..\..\..\..\sdk_580\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk_580\sdk\platform\driver\intc;.\..\..\..\..\..\sdk_580\sdk\platform\driver\inv;.\..\..\..\..\..\sdk_580\sdk\platform\driver\led;.\..\..\..\..\..\sdk_580\sdk\platform\driver\mc3410;.\..\..\..\..\..\sdk_580\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk_580\sdk\platform\driver\rc5;.\..\..\..\..\..\sdk_580\sdk\platform\driver\reg;.\..\..\..\..\..\sdk_580\sdk\platform\driver\sensor;.\..\..\..\..\..\sdk_580\sdk\platform\driver\spi;.\..\..\..\..\..\sdk_580\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk_580\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk_580\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk_580\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk_580\sdk\platform\driver\systick;.\..\..\..\..\..\sdk_580\sdk\platform\driver\trng;.\..\..\..\..\..\sdk_580\sdk\platform\driver\uart;.\..\..\..\..\..\sdk_580\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk_580\sdk\platform\core_modules\gtl\api;.\..\..\common\src;.\..\..\common\src\driver;.\..\..\common\src\profiles\spss
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\..\sdk_580\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk_580\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=empty_peripheral_template_580_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../sdk/platform/core_modules/arch_console/: arch_console.c
    ./../sdk/platform/core_modules/nvds/src/: nvds.c
    ./../sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_patch.c
    ./../sdk/platform/core_modules/wlan_coex/: wlan_coex.c
  group sdk_patches
    ./../sdk/platform/patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj llc.obj
  group sdk_driver
    ./../sdk/platform/driver/syscntl/: syscntl.c
    ./../sdk/platform/driver/gpio/: gpio.c
    ./../sdk/platform/driver/battery/: battery.c
    ./../sdk/platform/driver/adc/: adc.c
    ./../sdk/platform/driver/trng/: trng.c
    ./../sdk/platform/driver/systick/: systick.c
    ./../sdk/platform/driver/spi/: spi.c
    ./../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../sdk/platform/driver/spi_flash/: spi_flash.c
  group sdk_ble
    ./../sdk/platform/core_modules/rf/src/: rf_580.c
    ./../sdk/ble_stack/rwble/: rwble.c
    ./../sdk/platform/core_modules/rwip/src/: rwip.c
    ./../sdk/ble_stack/host/gap/gapm/: gapm.c
  group sdk_profiles
    ./../sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../sdk/ble_stack/profiles/: prf_utils.c
    ./../sdk/ble_stack/profiles/bas/bass/: bass.c bass_task.c
    ./../sdk/ble_stack/profiles/spota/spotar/: spotar.c spotar_task.c
    ./../sdk/ble_stack/profiles/dis/diss/: diss.c diss_task.c
  group sdk_app
    ./../sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ./../sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ./../sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../sdk/app_modules/src/app_spotar/: app_spotar.c app_spotar_task.c
    ./../sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h user_config_sw_ver.h user_custs_config.h
  group user_platform
    ./../src/platform/: user_periph_setup.c
    ./../src/: ADS1292.c AFE4400.c dsp.c ecgtohr.c
  group user_profiles
    ./../sdk/ble_stack/profiles/sps/spss/: sps_server.c sps_server_task.c
  group user_app
    ../src/: user_sps_device.c user_spss.c user_spss_task.c
target sps_device_581 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: sps_device_581 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14581__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: .\..\..\..\..\..\sdk_580\sdk\common_project_files\scatterfiles\scatterfile_common_581.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk_580\sdk\common_project_files\misc\rom_symdef_581.txt  --symdefs=empty_peripheral_template_581_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
target CBP310_583 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: CBP310_583 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14583__
  c misc: as above
  c include: .\..\;.\..\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\sdk\app_modules\api;.\..\sdk\app_modules\src\app_bass;.\..\sdk\app_modules\src\app_custs;.\..\sdk\app_modules\src\app_diss;.\..\sdk\app_modules\src\app_findme;.\..\sdk\app_modules\src\app_multi_bond;.\..\sdk\app_modules\src\app_proxr;.\..\sdk\app_modules\src\app_spotar;.\..\sdk\ble_stack\controller\em;.\..\sdk\ble_stack\controller\llc;.\..\sdk\ble_stack\controller\lld;.\..\sdk\ble_stack\controller\llm;.\..\sdk\ble_stack\hcic;.\..\sdk\ble_stack\hcih;.\..\sdk\ble_stack\host\att;.\..\sdk\ble_stack\host\att\attc;.\..\sdk\ble_stack\host\att\attm;.\..\sdk\ble_stack\host\att\atts;.\..\sdk\ble_stack\host\gap;.\..\sdk\ble_stack\host\gap\gapc;.\..\sdk\ble_stack\host\gap\gapm;.\..\sdk\ble_stack\host\gatt;.\..\sdk\ble_stack\host\gatt\gattc;.\..\sdk\ble_stack\host\gatt\gattm;.\..\sdk\ble_stack\host\l2c\l2cc;.\..\sdk\ble_stack\host\l2c\l2cm;.\..\sdk\ble_stack\host\smp\smpc;.\..\sdk\ble_stack\host\smp\smpm;.\..\sdk\ble_stack\host\smp;.\..\sdk\ble_stack\profiles\accel;.\..\sdk\ble_stack\profiles\adc_notify;.\..\sdk\ble_stack\profiles\anc\ancc;.\..\sdk\ble_stack\profiles\anc;.\..\sdk\ble_stack\profiles\anp\anpc;.\..\sdk\ble_stack\profiles\anp\anps;.\..\sdk\ble_stack\profiles\anp;.\..\sdk\ble_stack\profiles\bas\basc;.\..\sdk\ble_stack\profiles\bas\bass;.\..\sdk\ble_stack\profiles\blp\blpc;.\..\sdk\ble_stack\profiles\blp\blps;.\..\sdk\ble_stack\profiles\blp;.\..\sdk\ble_stack\profiles\cpp\cppc;.\..\sdk\ble_stack\profiles\cpp\cpps;.\..\sdk\ble_stack\profiles\cpp;.\..\sdk\ble_stack\profiles\cscp\cscpc;.\..\sdk\ble_stack\profiles\cscp\cscps;.\..\sdk\ble_stack\profiles\cscp;.\..\sdk\ble_stack\profiles\custom;.\..\sdk\ble_stack\profiles\custom\custs;.\..\sdk\ble_stack\profiles\device_config;.\..\sdk\ble_stack\profiles\dis\disc;.\..\sdk\ble_stack\profiles\dis\diss;.\..\sdk\ble_stack\profiles\find\findl;.\..\sdk\ble_stack\profiles\find\findt;.\..\sdk\ble_stack\profiles\glp\glpc;.\..\sdk\ble_stack\profiles\glp\glps;.\..\sdk\ble_stack\profiles\glp;.\..\sdk\ble_stack\profiles\hogp\hogpbh;.\..\sdk\ble_stack\profiles\hogp\hogpd;.\..\sdk\ble_stack\profiles\hogp\hogprh;.\..\sdk\ble_stack\profiles\hogp;.\..\sdk\ble_stack\profiles\hrp\hrpc;.\..\sdk\ble_stack\profiles\hrp\hrps;.\..\sdk\ble_stack\profiles\hrp;.\..\sdk\ble_stack\profiles\htp\htpc;.\..\sdk\ble_stack\profiles\htp\htpt;.\..\sdk\ble_stack\profiles\htp;.\..\sdk\ble_stack\profiles\ieu;.\..\sdk\ble_stack\profiles\lan\lanc;.\..\sdk\ble_stack\profiles\lan\lans;.\..\sdk\ble_stack\profiles\lan;.\..\sdk\ble_stack\profiles\mpu;.\..\sdk\ble_stack\profiles\pasp\paspc;.\..\sdk\ble_stack\profiles\pasp\pasps;.\..\sdk\ble_stack\profiles\pasp;.\..\sdk\ble_stack\profiles;.\..\sdk\ble_stack\profiles\prox\proxm;.\..\sdk\ble_stack\profiles\prox\proxr;.\..\sdk\ble_stack\profiles\rscp\rscpc;.\..\sdk\ble_stack\profiles\rscp\rscps;.\..\sdk\ble_stack\profiles\rscp;.\..\sdk\ble_stack\profiles\sample128;.\..\sdk\ble_stack\profiles\scpp\scppc;.\..\sdk\ble_stack\profiles\scpp\scpps;.\..\sdk\ble_stack\profiles\scpp;.\..\sdk\ble_stack\profiles\spota\spotar;.\..\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\sdk\ble_stack\profiles\tip\tipc;.\..\sdk\ble_stack\profiles\tip\tips;.\..\sdk\ble_stack\profiles\tip;.\..\sdk\ble_stack\profiles\uds\udss;.\..\sdk\ble_stack\profiles\uds;.\..\sdk\ble_stack\profiles\wpt\wptc;.\..\sdk\ble_stack\profiles\wpt\wpts;.\..\sdk\ble_stack\profiles\wpt;.\..\sdk\ble_stack\profiles\wss\wsss;.\..\sdk\ble_stack\rwble;.\..\sdk\ble_stack\rwble_hl;.\..\sdk\common_project_files;.\..\sdk\platform\arch;.\..\sdk\platform\arch\boot\rvds;.\..\sdk\platform\arch\compiler\rvds;.\..\sdk\platform\arch\ll\rvds;.\..\sdk\platform\arch\main;.\..\sdk\platform\arch;.\..\sdk\platform\core_modules\arch_console;.\..\sdk\platform\core_modules\common\api;.\..\sdk\platform\core_modules\crypto;.\..\sdk\platform\core_modules\dbg\api;.\..\sdk\platform\core_modules\gtl\src;.\..\sdk\platform\core_modules\ke\api;.\..\sdk\platform\core_modules\ke\src;.\..\sdk\platform\core_modules\nvds\api;.\..\sdk\platform\core_modules\rf\api;.\..\sdk\platform\core_modules\rwip\api;.\..\sdk\platform\core_modules\wlan_coex;.\..\sdk\platform\driver\accel;.\..\sdk\platform\driver\adc;.\..\sdk\platform\driver\battery;.\..\sdk\platform\driver\bme280;.\..\sdk\platform\driver\coex;.\..\sdk\platform\driver\coex;.\..\sdk\platform\driver\emi;.\..\sdk\platform\driver\gpio;.\..\sdk\platform\driver\i2c_BMI055;.\..\sdk\platform\driver\i2c_core;.\..\sdk\platform\driver\i2c_eeprom;.\..\sdk\platform\driver\intc;.\..\sdk\platform\driver\inv;.\..\sdk\platform\driver\led;.\..\sdk\platform\driver\mc3410;.\..\sdk\platform\driver\pwm;.\..\sdk\platform\driver\rc5;.\..\sdk\platform\driver\reg;.\..\sdk\platform\driver\sensor;.\..\sdk\platform\driver\spi;.\..\sdk\platform\driver\spi_439;.\..\sdk\platform\driver\spi_flash;.\..\sdk\platform\driver\spi_hci;.\..\sdk\platform\driver\syscntl;.\..\sdk\platform\driver\systick;.\..\sdk\platform\driver\trng;.\..\sdk\platform\driver\uart;.\..\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\sdk\platform\core_modules\gtl\api;.\..\..\common\src;.\..\..\common\src\driver;.\..\sdk\ble_stack\profiles\sps\spss;.\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: .\..\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=empty_peripheral_template_583_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
